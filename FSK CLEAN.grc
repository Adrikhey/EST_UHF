options:
  parameters:
    author: pi
    generate_options: qt_gui
    id: FSK_CLEAN
    output_language: python
    title: FSK DEMODULATION
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: '437500000'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    label: frequency
    start: '434000000'
    step: '100'
    stop: '438000000'
    value: '437000000'
  states: {state: disabled}
- name: freq_shift
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,1,1,1
    label: Manual frequency shift
    start: '-10000'
    step: '100'
    stop: '10000'
    value: '0'
  states: {}
- name: maxvalue
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: Waterfall maximum intensity
    start: '-100'
    step: '10'
    stop: '0'
    value: '-30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '96000'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_correctiq_0
  id: blocks_correctiq
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/pi/Documents/GNURADIO_REC/rec
    type: complex
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: freq_shift
    sample_rate: samp_rate
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: /home/pi/Documents/GNURADIO_REC/
    format: FORMAT_WAV
    nchan: '2'
    samp_rate: samp_rate
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/pi/Documents/GNURADIO_REC/grb.wav
    nchan: '2'
    repeat: 'True'
  states: {state: disabled}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_descrambler_bb_0_0_0
  id: digital_descrambler_bb
  parameters:
    len: '16'
    mask: '0x21'
    seed: '0x00'
  states: {}
- name: gpredict_MsgPairToVar_0_0
  id: gpredict_MsgPairToVar
  parameters:
    target: freq
  states: {}
- name: gpredict_doppler_0_0
  id: gpredict_doppler
  parameters:
    gpredict_host: 0.0.0.0
    gpredict_port: '4532'
    verbose: 'False'
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    addr: 127.0.0.1
    mode: '1'
    port: '2000'
    type: complex
  states: {state: disabled}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    gui_hint: 3,1,1,1
    key: freq
    label: Doppler corrected frequency
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    gui_hint: 0,1,1,1
    name: ''
    type: complex
    update_time: '0.04'
  states: {}
- name: qtgui_ledindicator_0
  id: qtgui_ledindicator
  parameters:
    gui_hint: 4,1,1,1
    label: '"AOS"'
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    gui_hint: 0,0,5,1
    int_max: maxvalue
    name: ''
    type: complex
    update_time: '0.04'
    wintype: window.WIN_HAMMING
  states: {}
- name: satellites_fsk_demodulator_0
  id: satellites_fsk_demodulator
  parameters:
    baudrate: '9600'
    iq: 'True'
    samp_rate: samp_rate
    subaudio: 'False'
  states: {}
- name: satellites_hdlc_deframer_1_0
  id: satellites_hdlc_deframer
  parameters:
    check_fcs: 'True'
    max_length: '10000'
  states: {}
- name: satellites_nrzi_decode_0_0
  id: satellites_nrzi_decode
  parameters: {}
  states: {}
- name: soapy_plutosdr_source_0
  id: soapy_plutosdr_source
  parameters:
    bandwidth: int(samp_rate)
    center_freq: freq
    gain: '60'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [blocks_complex_to_float_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_complex_to_float_0, '1', blocks_wavfile_sink_0, '1']
- [blocks_correctiq_0, '0', blocks_freqshift_cc_0, '0']
- [blocks_float_to_complex_0, '0', blocks_freqshift_cc_0, '0']
- [blocks_freqshift_cc_0, '0', blocks_complex_to_float_0, '0']
- [blocks_freqshift_cc_0, '0', blocks_file_sink_0, '0']
- [blocks_freqshift_cc_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_freqshift_cc_0, '0', qtgui_waterfall_sink_x_1, '0']
- [blocks_freqshift_cc_0, '0', satellites_fsk_demodulator_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [digital_binary_slicer_fb_0, '0', satellites_nrzi_decode_0_0, '0']
- [digital_descrambler_bb_0_0_0, '0', satellites_hdlc_deframer_1_0, '0']
- [gpredict_doppler_0_0, freq, gpredict_MsgPairToVar_0_0, inpair]
- [gpredict_doppler_0_0, freq, qtgui_edit_box_msg_0, val]
- [gpredict_doppler_0_0, state, blocks_message_debug_0_0, print]
- [gpredict_doppler_0_0, state, qtgui_ledindicator_0, state]
- [satellites_fsk_demodulator_0, '0', digital_binary_slicer_fb_0, '0']
- [satellites_hdlc_deframer_1_0, out, blocks_message_debug_0_1, print]
- [satellites_nrzi_decode_0_0, '0', digital_descrambler_bb_0_0_0, '0']
- [soapy_plutosdr_source_0, '0', blocks_correctiq_0, '0']
- [soapy_plutosdr_source_0, '0', network_tcp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
